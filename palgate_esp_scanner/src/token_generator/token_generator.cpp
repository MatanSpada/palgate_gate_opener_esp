#include "token_generator.h"
#include <vector>
#include <cstring>
#include <cstdio>
#include <ctime>
#include <sstream>
#include <iomanip>

static const uint8_t S_BOX[256] = {
  0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
  0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
  0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
  0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
  0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
  0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
  0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
  0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
  0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
  0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
  0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
  0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
  0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
  0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
  0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
  0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

static const uint8_t INVERSE_S_BOX[256] = {
  0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
  0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
  0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
  0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
  0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
  0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
  0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
  0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
  0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
  0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
  0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
  0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
  0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
  0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
  0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
  0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d
};

static const uint8_t RCON[10] = {0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36};

static const uint8_t T_C_KEY[16] = {
  0xfa,0xd3,0x25,0x72,0x81,0x29,0x00,0x00,0x00,0x00,0x00,0x00,0x3a,0xb4,0x5a,0x65
};

static const int BLOCK_SIZE = 16;
static const int KEY_SIZE = 16;
static const int TOKEN_SIZE = 23;
static const int TIMESTAMP_OFFSET_DEFAULT = 2;

// --- helpers ---
static inline uint8_t galoisMul2(uint8_t v) {
  return (v & 0x80) ? (((v << 1) ^ 0x1b) & 0xff) : ((v << 1) & 0xff);
}

static std::string bytesToHexUpper(const uint8_t* b, size_t len) {
  std::ostringstream oss;
  oss << std::uppercase << std::hex << std::setfill('0');
  for (size_t i = 0; i < len; ++i) {
    oss << std::setw(2) << static_cast<int>(b[i]);
  }
  return oss.str();
}

static void packUint64BE(uint64_t num, uint8_t out[8]) {
  for (int i = 7; i >= 0; --i) {
    out[i] = static_cast<uint8_t>(num & 0xffULL);
    num >>= 8;
  }
}


static void _aesEncDec(uint8_t state[16], uint8_t key[16], bool encrypt) {
    // if encrypt: initial AddRoundKey
  if (encrypt) {
    for (int rnd = 0; rnd < 10; ++rnd) {
      key[0] = (S_BOX[key[13]] ^ key[0] ^ RCON[rnd]) & 0xff;
      key[1] = (S_BOX[key[14]] ^ key[1]) & 0xff;
      key[2] = (S_BOX[key[15]] ^ key[2]) & 0xff;
      key[3] = (S_BOX[key[12]] ^ key[3]) & 0xff;
      for (int i = 4; i < KEY_SIZE; ++i) key[i] = (key[i] ^ key[i-4]) & 0xff;
    }
    for (int i = 0; i < BLOCK_SIZE; ++i) state[i] = (state[i] ^ key[i]) & 0xff;
  }

  for (int rnd = 0; rnd < 10; ++rnd) {
    if (encrypt) {
      for (int i = KEY_SIZE - 1; i > 3; --i) key[i] = (key[i] ^ key[i-4]) & 0xff;
      key[0] = (S_BOX[key[13]] ^ key[0] ^ RCON[9 - rnd]) & 0xff;
      key[1] = (S_BOX[key[14]] ^ key[1]) & 0xff;
      key[2] = (S_BOX[key[15]] ^ key[2]) & 0xff;
      key[3] = (S_BOX[key[12]] ^ key[3]) & 0xff;
    } else {
      for (int i = 0; i < BLOCK_SIZE; ++i) state[i] = S_BOX[state[i] ^ key[i]];
      // shift/row ops
      uint8_t buf1 = state[1];
      state[1] = state[5]; state[5] = state[9]; state[9] = state[13]; state[13] = buf1;

      uint8_t tmp1 = state[2], tmp2 = state[6];
      state[2] = state[10]; state[6] = state[14]; state[10] = tmp1; state[14] = tmp2;

      uint8_t tt = state[15];
      state[15] = state[11]; state[11] = state[7]; state[7] = state[3]; state[3] = tt;
    }

    if ((rnd > 0 && encrypt) || (!encrypt && rnd < 9)) {
      for (int i = 0; i < 4; ++i) {
        int base = i*4;
        if (encrypt) {
          uint8_t buf1 = galoisMul2(galoisMul2(state[base] ^ state[base+2]));
          uint8_t buf2 = galoisMul2(galoisMul2(state[base+1] ^ state[base+3]));
          state[base] = (state[base] ^ buf1) & 0xff;
          state[base+1] = (state[base+1] ^ buf2) & 0xff;
          state[base+2] = (state[base+2] ^ buf1) & 0xff;
          state[base+3] = (state[base+3] ^ buf2) & 0xff;
        }
        uint8_t mix = state[base] ^ state[base+1] ^ state[base+2] ^ state[base+3];
        uint8_t first = state[base];
        uint8_t buf3 = galoisMul2(state[base] ^ state[base+1]);
        state[base] = (state[base] ^ buf3 ^ mix) & 0xff;
        buf3 = galoisMul2(state[base+1] ^ state[base+2]);
        state[base+1] = (state[base+1] ^ buf3 ^ mix) & 0xff;
        buf3 = galoisMul2(state[base+2] ^ state[base+3]);
        state[base+2] = (state[base+2] ^ buf3 ^ mix) & 0xff;
        buf3 = galoisMul2(state[base+3] ^ first);
        state[base+3] = (state[base+3] ^ buf3 ^ mix) & 0xff;
      }
    }

    if (encrypt) {
      uint8_t b1 = state[13];
      state[13] = state[9]; state[9] = state[5]; state[5] = state[1]; state[1] = b1;

      uint8_t t1 = state[10], t2 = state[14];
      state[10] = state[2]; state[14] = state[6]; state[2] = t1; state[6] = t2;

      uint8_t t = state[3];
      state[3] = state[7]; state[7] = state[11]; state[11] = state[15]; state[15] = t;

      for (int i = 0; i < BLOCK_SIZE; ++i) state[i] = (INVERSE_S_BOX[state[i]] ^ key[i]) & 0xff;
    } else {
      key[0] = (S_BOX[key[13]] ^ key[0] ^ RCON[rnd]) & 0xff;
      key[1] = (S_BOX[key[14]] ^ key[1]) & 0xff;
      key[2] = (S_BOX[key[15]] ^ key[2]) & 0xff;
      key[3] = (S_BOX[key[12]] ^ key[3]) & 0xff;
      for (int i = 4; i < KEY_SIZE; ++i) key[i] = (key[i] ^ key[i-4]) & 0xff;
    }
  }

  if (!encrypt) {
    for (int i = 0; i < BLOCK_SIZE; ++i) state[i] = (state[i] ^ key[i]) & 0xff;
  }
}

static std::array<uint8_t, 16> aesEncryptDecrypt(const uint8_t stateIn[16], const uint8_t keyIn[16], bool encrypt) {
  uint8_t state[16]; uint8_t key[16];
  memcpy(state, stateIn, 16); memcpy(key, keyIn, 16);
  _aesEncDec(state, key, encrypt);
  std::array<uint8_t,16> out;
  memcpy(out.data(), state, 16);
  return out;
}

static std::array<uint8_t,16> step1(const uint8_t sessionToken[16], uint64_t phoneNumber) {
  uint8_t key[16];
  memcpy(key, T_C_KEY, 16);
  uint8_t phonePacked[8];
  packUint64BE(phoneNumber, phonePacked);
  // replace key[6..11] with phonePacked[2..7]
  for (int i = 0; i < 6; ++i) key[6 + i] = phonePacked[2 + i];
  std::array<uint8_t,16> res = aesEncryptDecrypt(sessionToken, key, true);
  return res;
}

static std::array<uint8_t,16> step2(const std::array<uint8_t,16>& resultFromStep1, uint32_t timestampSecs, int timestampOffset) {
  uint8_t nextState[16]; memset(nextState, 0, 16);
  const uint16_t val16 = 0xa0a;
  nextState[1] = val16 & 0xff;
  nextState[2] = (val16 >> 8) & 0xff;
  uint32_t val32 = timestampSecs + timestampOffset;
  nextState[10] = (val32 >> 24) & 0xff;
  nextState[11] = (val32 >> 16) & 0xff;
  nextState[12] = (val32 >> 8) & 0xff;
  nextState[13] = val32 & 0xff;
  uint8_t key[16]; memcpy(key, resultFromStep1.data(), 16);
  std::array<uint8_t,16> out = aesEncryptDecrypt(nextState, key, false);
  return out;
}

std::string generateToken(const uint8_t sessionToken[16], uint64_t phoneNumber, int tokenType, uint32_t timestampSecs, int timestampOffset) {
  if (timestampSecs == 0) timestampSecs = static_cast<uint32_t>(time(nullptr));
  std::array<uint8_t,16> step2Key = step1(sessionToken, phoneNumber);
  std::array<uint8_t,16> step2Result = step2(step2Key, timestampSecs, timestampOffset);

  uint8_t result[TOKEN_SIZE];
  memset(result, 0, TOKEN_SIZE);
  if (tokenType == 0) result[0] = 0x01;
  else if (tokenType == 1) result[0] = 0x11;
  else if (tokenType == 2) result[0] = 0x21;
  else result[0] = 0x11;

  uint8_t phonePacked[8]; packUint64BE(phoneNumber, phonePacked);
  // copy bytes 2..7 into result[1..6]
  for (int i = 0; i < 6; ++i) result[1 + i] = phonePacked[2 + i];

  // set bytes 7..22 = step2Result (16 bytes)
  for (int i = 0; i < 16; ++i) result[7 + i] = step2Result[i];

  return bytesToHexUpper(result, TOKEN_SIZE);
}

bool hexStringToBytes(const std::string &hex, uint8_t *out, size_t outLen) {
  if (hex.size() < outLen*2) return false;
  for (size_t i = 0; i < outLen; ++i) {
    unsigned int byte;
    if (sscanf(hex.c_str() + 2*i, "%2x", &byte) != 1) return false;
    out[i] = static_cast<uint8_t>(byte);
  }
  return true;
}
// --- end of token_generator.cpp ---